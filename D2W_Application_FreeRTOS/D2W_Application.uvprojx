# Keil uVision project D2W_Application.uvprojx, settings and files
target Target_1 (6160000::V6.16::ARMCLANG)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08008000,0x0001B000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: D2W_Application +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F30X_HD
  c include: .\Config;.\BSP;.\App;.\Common;.\User;.\Middlewares\FreeRTOS-Kernel\include;.\Middlewares\FreeRTOS-Kernel\portable\GCC\ARM_CM4F;.\Libraries\GD32F30x_Firmware_Library_V2.1.5\Firmware\CMSIS;.\Libraries\GD32F30x_Firmware_Library_V2.1.5\Firmware\CMSIS\GD\GD32F30x\Include;.\Libraries\GD32F30x_Firmware_Library_V2.1.5\Firmware\GD32F30x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x1b000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c
  group BSP
    ./BSP/: systick.c systick.h board_pins.h gd32f30x_libopt.h
  group Application
    ./App/: app_boot_control.c app_boot_control.h freertos_app.c freertos_app.h system_tasks.c system_tasks.h orin_status.c orin_status.h power_ctrl.c power_ctrl.h power_fail.c power_fail.h rtc_calendar.c rtc_calendar.h shutdown_request.c shutdown_request.h voltage_monitor.c voltage_monitor.h watchdog_ctrl.c watchdog_ctrl.h
  group Common
    ./Common/: boot_shared.h
  group Config
    ./Config/: FreeRTOSConfig.h
  group FreeRTOS_Kernel
    ./Middlewares/FreeRTOS-Kernel/: tasks.c queue.c list.c event_groups.c timers.c
  group FreeRTOS_Port
    ./Middlewares/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
  group Startup
    ./Libraries/GD32F30x_Firmware_Library_V2.1.5/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group System
    ./Libraries/GD32F30x_Firmware_Library_V2.1.5/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32_Driver
    ./Libraries/GD32F30x_Firmware_Library_V2.1.5/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_rcu.c gd32f30x_gpio.c gd32f30x_adc.c gd32f30x_exti.c gd32f30x_pmu.c gd32f30x_fmc.c gd32f30x_i2c.c gd32f30x_bkp.c gd32f30x_misc.c
