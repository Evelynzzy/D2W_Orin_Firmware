# Keil uVision project D2W_Bootloader.uvprojx, settings and files
target Target_1 (6160000::V6.16::ARMCLANG)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: D2W_Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F30X_HD
  c include: .\Inc;.\Common;.\Libraries\GD32F30x_Firmware_Library_V2.1.5\Firmware\CMSIS;.\Libraries\GD32F30x_Firmware_Library_V2.1.5\Firmware\CMSIS\GD\GD32F30x\Include;.\Libraries\GD32F30x_Firmware_Library_V2.1.5\Firmware\GD32F30x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Bootloader_Source
    ./Src/: boot_crc32.c boot_flash.c boot_image.c boot_jump.c boot_metadata.c boot_protocol.c boot_request.c boot_time.c boot_uart.c boot_watchdog.c main.c
  group Bootloader_Headers
    ./Inc/: boot_config.h boot_crc32.h boot_flash.h boot_image.h boot_jump.h boot_metadata.h boot_protocol.h boot_request.h boot_time.h boot_uart.h boot_watchdog.h gd32f30x_libopt.h
    ./Common/: boot_shared.h
  group Startup
    ./Libraries/GD32F30x_Firmware_Library_V2.1.5/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group System
    ./System/: system_gd32f30x.c
  group GD32_Driver
    ./Libraries/GD32F30x_Firmware_Library_V2.1.5/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_rcu.c gd32f30x_gpio.c gd32f30x_usart.c gd32f30x_fmc.c gd32f30x_pmu.c gd32f30x_bkp.c
